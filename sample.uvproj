# Keil uVision project sample.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: sample
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: sample.c
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group button_EINT
    ./button_EXINT/: button.h IRQ_button.c lib_button.c
  group timer
    ./timer/: IRQ_timer.c lib_timer.c timer.h
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group adc
    ./adc/: adc.h IRQ_adc.c lib_adc.c
  group GLCD_TP
    ./GLCD_TP/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group game
    ./: game.h game.c
